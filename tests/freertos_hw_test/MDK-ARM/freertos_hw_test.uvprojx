# Keil uVision project freertos_hw_test.uvprojx, settings and files
target freertos_hw_test (6240000::V6.24::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: freertos_hw_test +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../../../firmware/RTSFR/Inc;../../../firmware/Drivers/STM32F1xx_HAL_Driver/Inc;../../../firmware/Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../../../firmware/Middlewares/Third_Party/FreeRTOS/Source/include;../../../firmware/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../../../firmware/Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM3;../../../firmware/Drivers/CMSIS/Device/ST/STM32F1xx/Include;../../../firmware/Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c freertos.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Drivers/STM32F1xx_HAL_Driver
    ../../../firmware/Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Middlewares/FreeRTOS
    ../../../firmware/Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../firmware/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../../../firmware/Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../firmware/Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM3/: port.c
  group RTSFR/Core
    ../../../firmware/RTSFR/Src/: rtsfr_detect.c rtsfr_policy.c rtsfr_resource.c rtsfr_recovery.c rtsfr_safe_mode.c
